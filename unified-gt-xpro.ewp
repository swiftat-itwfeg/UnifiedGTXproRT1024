# IAR project unified-gt-xpro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1024xxx5A NXP MIMXRT1024xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1024DAG5A; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; USB_STACK_FREERTOS; USB_STACK_FREERTOS_HEAP_SIZE=32768; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: board; CMSIS; drivers; freertos\freertos_kernel\include; freertos\freertos_kernel\portable\IAR\ARM_CM4F; freertos\freertos_kernel\portable\MemMang; include; MIMXRT1024\device; startup; utilities; utilities\common; utilities\common\uart; source\usb\include; source\usb\device\include; source\usb\device\source\ehci; source\usb\device\source\dci; components\osa; components\list; source\usb\device\source; source\usb\phy; components\exceptions; include\avery; include\common; include\hobart; mimxrt1024\periph; cmsis\m-profile
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: include; include\common
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: MIMXRT1024\linker\MIMXRT1024xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group cmsis
    cmsis/: cmsis_clang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group cmsis/m-profile
    cmsis/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_clang_m.h cmsis_iccarm_m.h
  group components/exceptions
    components/exceptions/: fsl_component_exception_handling.c fsl_component_exception_handling.h
  group components/list
    components/list/: fsl_component_generic_list.c fsl_component_generic_list.h
  group components/osa
    components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group drivers
    drivers/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_flexio.c fsl_flexio.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexram_allocate.c fsl_flexram_allocate.h fsl_flexspi.c fsl_flexspi.h fsl_flexspi_edma.c fsl_flexspi_edma.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpi2c_freertos.c fsl_lpi2c_freertos.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpspi_freertos.c fsl_lpspi_freertos.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_lpuart_freertos.c fsl_lpuart_freertos.h fsl_nic301.h fsl_ocotp.c fsl_ocotp.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_qtmr.c fsl_qtmr.h fsl_romapi.c fsl_romapi.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group freertos/freertos_kernel
    freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable/iar/arm_cm4f
    freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/memMang
    freertos/freertos_kernel/portable/MemMang/: heap_4.c
  group include
    include/: printEngine.h printHead.h takeupMotor.h TPHMotor.h unitTest.h
  group include/avery
    include/avery/: averyAuditLog.h averyCutter.h averyFilter.h averyLabel.h averyPrinterCfg.h averyPrinterTask.h averyProtocol.h averyPrStatus.h averyScaleCfg.h averyUtils.h averyWeigherCfg.h averyWeigherTask.h averyWgStatus.h diagnostics.h
  group include/common
    include/common/: cs5530.h deviceProperties.h dvr8818.h eep93C56.h FreeRTOSConfig.h idleTask.h internalMessages.h lp5521.h queueManager.h realtimeClock.h sca3300Accel.h sensors.h serialFlash.h systemTimer.h threadManager.h translator.h unifiedProtocol.h usbTask.h vendor.h w25x10cl.h
  group include/hobart
    include/hobart/: boxcarFilter.h boxcarFilterF.h cat3Audit.h commandTable.h dotWearTask.h drawingPrimitives.h edgeDetection.h firFilter.h hobartPrinter.h hobartPrinterMessages.h hobartPrinterTask.h hobartProtocol.h hobartWeigherCfg.h hobartWeigherMessages.h hobartWeigherTask.h label.h valueMax.h varGainFilter.h weigher.h
  group mimxrt1024/device
    mimxrt1024/device/: fsl_device_registers.h MIMXRT1024.h MIMXRT1024_COMMON.h MIMXRT1024_features.h system_MIMXRT1024.c system_MIMXRT1024.h
  group mimxrt1024/linker
    mimxrt1024/linker/: MIMXRT1024xxxxx_flexspi_nor.icf MIMXRT1024xxxxx_flexspi_nor_sdram.icf MIMXRT1024xxxxx_ram.icf MIMXRT1024xxxxx_sdram.icf MIMXRT1024xxxxx_sdram_txt.icf
  group mimxrt1024/periph
    mimxrt1024/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_USB.h PERI_USB_ANALOG.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group source/printer
    source/printer/: averyCutter.c commandTable.c developmentTools.c dotWearTask.c drawingPrimitives.c printEngine.c printHead.c takeupMotor.c testLabel.c TPHMotor.c
  group source/printer/avery
    source/printer/avery/: averyPrinterTask.c averyPrStatus.c
  group source/printer/hobart
    source/printer/hobart/: hobartPrinterTask.c
  group source/system/avery
    source/system/avery/: diagnostics.c
  group source/system/common
    source/system/common/: dvr8818.c idleTask.c lp5521.c queueManager.c realtimeClock.c sensors.c serialFlash.c systemTimer.c threadManager.c translator.c vendor.c w25x10cl.c
  group source/system/hobart
    source/system/hobart/: cat3Audit.c
  group source/valueMax
    source/valueMax/: eep93C56.c sca3300Accel.c valueMax.c
  group source/weigher/hobart
    source/weigher/hobart/: boxcarFilter.c boxcarFilterF.c edgeDetection.c firFilter.c hobartWeigherTask.c varGainFilter.c
  group startup
    startup/: startup_MIMXRT1024.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group utilities/common
    utilities/common/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group utilities/common/uart
    utilities/common/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group xip
    xip/: evkmimxrt1024_flexspi_nor_config.c evkmimxrt1024_flexspi_nor_config.h
